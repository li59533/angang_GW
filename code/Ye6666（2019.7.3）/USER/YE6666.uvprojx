# Keil uVision project YE6666.uvprojx, settings and files
target YE6666 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YE6271_New +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\SRAM;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\USMART;..\LWIP;..\LWIP\app;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip_app\udp_demo;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\MALLOC;..\HARDWARE\AD7606;..\HARDWARE\CAN;..\HARDWARE\RS485;..\HARDWARE\SPI;..\HARDWARE\GPIO;..\HARDWARE\CAN;..\COMMAND;..\FLASH;..\MODULE_1;..\MODULE_2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c app.h
    ../COMMAND/: command.c paramaters.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ./: rtc.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/CAN/: can.c
  group FLASH
    ../FLASH/: STM32F4_Flash.c STM32F4_Flash.h
  group MODULE_1
    ../MODULE_1/: module_1.c module_1.h
  group MODULE_2
    ../MODULE_2/: module_2.c module_2.h
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_rtc.c stm32f4xx_pwr.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../FWLIB/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rtc.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/udp_demo/: udp_server.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group MALLOC
    ../MALLOC/: malloc.c
